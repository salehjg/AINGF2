# Keil uVision project AINGF2_FIRMWARE.uvproj, settings and files
target Target 1 (MCS-51)
  device: 8051 IP Core Oregano Systems
  cpu: IRAM(0-0x7F) XRAM(0-0xFFFF) IROM(0-0xFFF) CLOCK(12000000)
  output: AINGF2_FIRMWARE +hex
  AfterMake: F:\Saleh\Saleh_Files\FPGA\Boards\02_AINGF_V2\01_VerilogPRJ\CamCTRLR_SRAM_CENTER_V2\00_Codes\m8051_IP\01_FIRMWARE\01_PRJ\Objects\Converter.exe #H
  c include: .\00_CODES;.\00_CODES\01_MAIN;.\00_CODES\02_DELAY;.\00_CODES\03_CORE;.\00_CODES\04_MEMORY
  group General
    ./00_CODES/01_MAIN/: main.c
  group Utility
    ./00_CODES/02_DELAY/: delay.c
  group CORE
    ./00_CODES/03_CORE/: core.c
  group MEMORY
    ./00_CODES/04_MEMORY/: mem.c
